# Keil uVision project uart.uvprojx, settings and files
target uart (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: uart
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Objects\uart.bin .\Objects\uart.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\PERIPHREAL\Includes;..\STARTUP;..\SYSTEM;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../STARTUP/: startup_gw1ns4c.s
  group CORE
    ../CORE/: core_cm3.c
  group SYSTEM
    ../SYSTEM/: system_gw1ns4c.c
  group PERIPHERAL
    ../PERIPHREAL/Sources/: gw1ns4c_gpio.c gw1ns4c_i2c.c gw1ns4c_misc.c gw1ns4c_rtc.c gw1ns4c_syscon.c gw1ns4c_timer.c gw1ns4c_uart.c gw1ns4c_wdog.c
  group USER
    ../USER/: main.c gw1ns4c_it.c retarget.c
